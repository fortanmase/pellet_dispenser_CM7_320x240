# Keil uVision project pellet_dispenser_CM7_320x240.uvprojx, settings and files
target pellet_dispenser_CM7_320x240_CM4 (6190000::V6.19::ARMCLANG)
  device: STM32H755ZITx:CM4 STMicroelectronics
  pack: Keil.STM32H7xx_DFP.3.1.1
  cpu: IRAM(0x10000000-0x10047FFF) IRAM2(0x18000000-0x1800FFFF) IROM(0x8100000-0x81FFFFF) CLOCK(12000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: pellet_dispenser_CM7_320x240_CM4 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=5 wLevel=3
  c define: CORE_CM4,USE_HAL_DRIVER,STM32H755xx
  c include: ../CM4/Core/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32H7xx/Include;../Drivers/CMSIS/Include
  asm include: ../CM4/Core/Inc
  memory RVCT4: ROM 0x8100000 size 0x100000
  memory RVCT9: RAM 0x10000000 size 0x48000
  memory RVCT10: RAM 0x18000000 size 0x10000
  scatter file: stm32h755xx_flash_CM4.sct
  group Application/MDK-ARM
    ./: startup_stm32h755xx_CM4.s startup_stm32h755xx_CM7.s
  group Application/User/CM4/Core
    ../CM4/Core/Src/: main.c stm32h7xx_it.c stm32h7xx_hal_msp.c
  group Application/User/CM7/Core
    ../CM7/Core/Src/: st7789.c cst328.c main.c freertos.c stm32h7xx_it.c stm32h7xx_hal_msp.c
  group Drivers/STM32H7xx_HAL_Driver
    ../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal_cortex.c stm32h7xx_hal_crc.c stm32h7xx_hal_crc_ex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hsem.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_exti.c stm32h7xx_hal_eth.c stm32h7xx_hal_eth_ex.c stm32h7xx_hal_spi.c stm32h7xx_hal_spi_ex.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c stm32h7xx_hal_pcd.c stm32h7xx_hal_pcd_ex.c stm32h7xx_ll_usb.c
  group Drivers/CMSIS
    ../Common/Src/: system_stm32h7xx_dualcore_boot_cm4_cm7.c
  group Application/User/CM7/TouchGFX/App
    ../CM7/TouchGFX/App/: app_touchgfx.c
  group Application/User/CM7/TouchGFX/target
    ../CM7/TouchGFX/target/: TouchGFX_DataTransfer.c TouchGFXHAL.cpp STM32TouchController.cpp TouchGFXGPIO.cpp
  group Application/User/CM7/TouchGFX/target/generated
    ../CM7/TouchGFX/target/generated/: TouchGFXConfiguration.cpp TouchGFXGeneratedHAL.cpp STM32DMA.cpp OSWrappers.cpp
  group gui
    ../cm7/touchgfx/gui/src/common/: frontendapplication.cpp
    ../cm7/touchgfx/gui/src/main_screen/: mainpresenter.cpp mainview.cpp
    ../cm7/touchgfx/gui/src/model/: model.cpp
  group generated
    ../cm7/touchgfx/generated/fonts/src/: applicationfontprovider.cpp cachedfont.cpp font_tcbi_____ttf_26_4bpp_0.cpp font_tcbi_____ttf_28_4bpp_0.cpp font_tcbi_____ttf_30_4bpp_0.cpp font_tcmi_____ttf_20_4bpp_0.cpp font_tcmi_____ttf_26_4bpp_0.cpp font_verdana_10_4bpp_0.cpp font_verdana_20_4bpp_0.cpp font_verdana_40_4bpp_0.cpp fontcache.cpp generatedfont.cpp kerning_tcbi_____ttf_26_4bpp.cpp kerning_tcbi_____ttf_28_4bpp.cpp kerning_tcbi_____ttf_30_4bpp.cpp kerning_tcmi_____ttf_20_4bpp.cpp kerning_tcmi_____ttf_26_4bpp.cpp kerning_verdana_10_4bpp.cpp kerning_verdana_20_4bpp.cpp kerning_verdana_40_4bpp.cpp table_tcbi_____ttf_26_4bpp.cpp table_tcbi_____ttf_28_4bpp.cpp table_tcbi_____ttf_30_4bpp.cpp table_tcmi_____ttf_20_4bpp.cpp table_tcmi_____ttf_26_4bpp.cpp table_verdana_10_4bpp.cpp table_verdana_20_4bpp.cpp table_verdana_40_4bpp.cpp unmappeddatafont.cpp
    ../cm7/touchgfx/generated/images/src/: bitmapdatabase.cpp image_brightness_pressed_32x32.cpp image_brightness_released_32x32.cpp image_button_pressed_110x50.cpp image_button_pressed_320x42.cpp image_button_pressed_50x30.cpp image_button_released_110x50.cpp image_button_released_320x42.cpp image_button_released_50x30.cpp image_chevron_down_released_40px.cpp image_chevron_left_pressed_40px.cpp image_chevron_left_released_40px.cpp image_chevron_right_pressed_40px.cpp image_chevron_right_released_40px.cpp image_failure_48x48.cpp image_home_pressed_36px.cpp image_home_released_36px.cpp image_info_pressed_36px.cpp image_info_released_36px.cpp image_loading_48x48.cpp image_metris_logo.cpp image_pellets3_pressed_32x32.cpp image_pellets3_released_32x32.cpp image_pellets7_pressed_32x32.cpp image_pellets7_released_32x32.cpp image_ready_48x48.cpp image_reset_pressed_48x48.cpp image_reset_released_48x48.cpp image_settings_pressed_36px.cpp image_settings_released_36px.cpp image_slider_background.cpp image_slider_fill.cpp image_slider_indicator.cpp image_sound_pressed_32x32.cpp image_sound_released_32x32.cpp image_toggle_button_off_50x30.cpp image_toggle_button_on_50x30.cpp image_warning_48x48.cpp svgdatabase.cpp
    ../cm7/touchgfx/generated/gui_generated/src/common/: frontendapplicationbase.cpp
    ../cm7/touchgfx/generated/images/src/__generated/: image_icon_theme_images_action_autorenew_50_50_e8f6fb.svg.cpp image_icon_theme_images_action_pan_tool_45_45_e8f6fb.svg.cpp
    ../cm7/touchgfx/generated/texts/src/: languagegb.cpp texts.cpp typedtextdatabase.cpp
    ../cm7/touchgfx/generated/gui_generated/src/main_screen/: mainviewbase.cpp
  group Lib
    ../cm7/middlewares/st/touchgfx/lib/core/cortex_m7/Keil6.x/: touchgfx_core_wchar16.lib
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/GCC/ARM_CM4F/: port.c
target pellet_dispenser_CM7_320x240_CM7 (6190000::V6.19::ARMCLANG)
  device: STM32H755ZITx:CM7 STMicroelectronics
  pack: Keil.STM32H7xx_DFP.3.1.1
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x00000000-0xFFFF) IROM(0x8000000-0x80FFFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE TZ
  output: pellet_dispenser_CM7_320x240_CM7 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=5 wLevel=3
  c define: CORE_CM7,USE_HAL_DRIVER,STM32H755xx
  c include: ../CM7/Core/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32H7xx/Include;../Drivers/CMSIS/Include;../CM7/TouchGFX/App;../CM7/TouchGFX/target/generated;../CM7/TouchGFX/target;../cm7/middlewares/st/touchgfx/framework/include;../cm7/touchgfx/generated/fonts/include;../cm7/touchgfx/generated/gui_generated/include;../cm7/touchgfx/generated/images/include;../cm7/touchgfx/generated/texts/include;../cm7/touchgfx/generated/videos/include;../cm7/touchgfx/gui/include;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/portable/GCC/ARM_CM4F;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS
  asm include: ../CM7/Core/Inc
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x24000000 size 0x80000
  memory RVCT10: RAM 0x0 size 0x10000
  scatter file: stm32h755xx_flash_CM7.sct
software components: CMSIS:CORE 5.6.0
